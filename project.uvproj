# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c MatrixKey.c Delay.c Delay.h MatrixKey.h oled.c oled.h menu.c menu.h display_menu1.c display_menu1.h oledfont.h display_menu2.c display_menu2.h display_menu3.c display_menu3.h
